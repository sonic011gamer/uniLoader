## configs/saana_defconfig
```kconfig
CONFIG_CROSS_COMPILE="arm-none-eabi-"
CONFIG_MICROSOFT_SAANA=y
CONFIG_QUALCOMM_MSM8909=y
```
